# Keil uVision project room-area-calculation-project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: LM3S1968 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: room-area-calculation-project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./Sources/: main.s bumpers.s leds.s switches.s timer.s engine.s
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
